require ${BPN}.inc
require ${BP}-crates.inc

SRCREV = "b4da0c084cca370172710454db1ef4cd63c1759b"

RUST_MSRV = "1.93.0"
