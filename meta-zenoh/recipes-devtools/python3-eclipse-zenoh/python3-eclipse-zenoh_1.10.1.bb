require ${BPN}.inc
require ${BP}-crates.inc

SRCREV = "9ee7cef61031ad518cd54ca3ea3141a772b1cd79"

RUST_MSRV = "1.88.0"
