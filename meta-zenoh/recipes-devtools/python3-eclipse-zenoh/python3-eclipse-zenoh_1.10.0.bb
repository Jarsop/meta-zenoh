require ${BPN}.inc
require ${BP}-crates.inc

SRCREV = "3bb1404d7ced4d21b7d6ae19572f32b77dc63b4f"

RUST_MSRV = "1.88.0"
