require ${BPN}.inc
require ${BP}-crates.inc

SRCREV = "32f682af928662c770f0ccfcdea02fb8513a83e7"

RUST_MSRV = "1.89.0"
