require ${BPN}.inc
require ${BP}-crates.inc

SRCREV = "0659dbd3733f6af06307785ccd2f3bcc171bc75f"

RUST_MSRV = "1.93.0"
