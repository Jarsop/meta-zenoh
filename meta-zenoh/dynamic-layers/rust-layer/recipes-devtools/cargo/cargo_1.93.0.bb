require dynamic-layers/rust-layer/recipes-devtools/rust/rust-source-${PV}.inc
require dynamic-layers/rust-layer/recipes-devtools/rust/rust-snapshot-${PV}.inc
require recipes-devtools/cargo/cargo.inc
BBCLASSEXTEND = "native nativesdk"
