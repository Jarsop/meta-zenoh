require ${BPN}.inc
require ${BP}-crates.inc

SRCREV = "95af166fc0b8b1682437af908b0a1ef58839afb9"

SRC_URI += "\
    file://0004-add-USES_TERMINAL-for-Ninja-build.patch \
"
