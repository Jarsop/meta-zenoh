require ${BPN}.inc
require ${BP}-crates.inc

SRC_URI += "file://0003-use-frozen-in-opaque_types_generator.rs.patch"

SRCREV = "f376456ccf75ed837a21a186bdf5191cba50eb3b"
