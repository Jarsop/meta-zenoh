require ${BPN}.inc
require ${BP}-crates.inc

SRC_URI += "file://0003-use-frozen-and-set-right-soname-in-build.rs.patch"

SRCREV = "449410d48be6c008296ea1405681a1d952907a7e"
