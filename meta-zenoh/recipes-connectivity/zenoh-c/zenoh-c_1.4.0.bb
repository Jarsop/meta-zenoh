require ${BPN}.inc
require ${BP}-crates.inc

SRC_URI += "file://0003-use-frozen-in-opaque_types_generator.rs.patch"

SRCREV = "0d33f530130c36afd76c2bb2270ca15e3a332f71"
