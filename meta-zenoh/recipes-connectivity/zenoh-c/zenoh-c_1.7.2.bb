require ${BPN}.inc
require ${BP}-crates.inc

SRC_URI += "file://0003-use-frozen-in-opaque_types_generator.rs.patch"

SRCREV = "955d88fabfd12407e3a5f9ad38cf251ad0aeedb8"
