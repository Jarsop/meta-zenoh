require ${BPN}.inc
require ${BP}-crates.inc

SRC_URI += "file://0003-use-frozen-in-opaque_types_generator.rs.patch"

SRCREV = "73e7a0bdcf78b8263a02b7aee453ee6de8187589"
