require ${BPN}.inc
require ${BP}-crates.inc

SRC_URI += "file://0003-use-frozen-in-opaque_types_generator.rs.patch"

SRCREV = "8f9ce70e4c4b55d150632730fd4c48abffbde765"
