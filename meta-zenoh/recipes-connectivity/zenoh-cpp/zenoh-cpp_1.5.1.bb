require ${BPN}.inc

SRCREV = "05533d20db70ffc1d53a0e07f39caa999e82febd"
