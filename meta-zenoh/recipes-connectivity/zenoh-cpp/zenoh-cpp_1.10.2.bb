require ${BPN}.inc

SRCREV = "20eb0bef670e150d3750ca0739dcb28cd7909e2e"
