require ${BPN}.inc

SRCREV = "89760e6b0de481fe899b181deb450a926fcbc019"
