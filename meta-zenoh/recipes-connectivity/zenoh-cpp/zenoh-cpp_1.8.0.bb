require ${BPN}.inc

SRCREV = "c3f98b7fad41bd91b7eb845d7853faadaf2249a5"
