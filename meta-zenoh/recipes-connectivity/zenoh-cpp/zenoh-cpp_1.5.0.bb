require ${BPN}.inc

SRCREV = "a96589bfabce428fca1f915a8aa51dc4340545f9"
