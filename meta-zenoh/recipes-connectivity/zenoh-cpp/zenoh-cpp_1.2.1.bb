require ${BPN}.inc

SRCREV = "3f11bc5900efd39b816c9762be44f8193c250f47"
