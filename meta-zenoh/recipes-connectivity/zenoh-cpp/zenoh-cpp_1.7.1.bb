require ${BPN}.inc

SRCREV = "47a80d345d74ebef16f3783423bf3bbd89cd6c30"
