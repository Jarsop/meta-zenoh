require ${BPN}.inc

SRCREV = "0cd54f291039a65b96921a5951a66aeef088e67c"
