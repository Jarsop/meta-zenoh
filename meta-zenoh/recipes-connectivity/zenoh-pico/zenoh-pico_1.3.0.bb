require ${BPN}.inc

SRCREV = "1cf4f92f3687b3a2dbd013fc08311e31c60b7df7"
