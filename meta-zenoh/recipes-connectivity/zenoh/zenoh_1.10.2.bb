require ${BPN}.inc
require ${BP}-crates.inc

SRCREV = "cc839802639e3b7ebea50990f7a819fe8990b0fe"

RUST_MSRV = "1.75.0"
