require ${BPN}.inc
require ${BP}-crates.inc

SRCREV = "81c6c933b6e41d72a05f04c4442ef57717ddc72b"

RUST_MSRV = "1.75.0"
