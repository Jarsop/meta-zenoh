require ${BPN}.inc
require ${BP}-crates.inc

SRCREV = "49c8a538da0b965b337ee169bb70eb3cf3523c4c"
