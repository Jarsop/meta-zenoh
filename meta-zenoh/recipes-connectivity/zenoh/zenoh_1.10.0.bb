require ${BPN}.inc
require ${BP}-crates.inc

SRCREV = "c479f0c1102d7321c2fa83f515bddede92014cce"

RUST_MSRV = "1.75.0"
