require ${BPN}.inc
require ${BP}-crates.inc

SRCREV = "1211779c3647f5a96713dade452c546a07823580"

RUST_MSRV = "1.75.0"
